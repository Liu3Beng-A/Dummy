#include <cstdint>
#define private public
#include "stream_curve.h"
#undef private
#include "stream_curve_hold_oracle.h"
#include "stream_curve_float_1401_oracle.h"
#include <climits>
#include <cstdio>
#include <cstdlib>
#include <cmath>
#include <cstdint>
#include <random>
#include <algorithm>

using MotorStream::Point;
static uint64_t checks, accepted, rejected, floatDifferentQ, floatDifferentV;
static uint64_t legacyDifferentQ, legacyDifferentV, exactFixtureTicks;
static long double maxQ40ErrorQ, maxQ40ErrorV, maxOutputErrorQ, maxOutputErrorV;
#define CHECK(x) do { ++checks; if (!(x)) { std::fprintf(stderr,"FAIL line%u %s\n",__LINE__,#x); std::exit(1); } } while(0)
constexpr long double Scale=1099511627776.0L;
constexpr long double PositionBound=0.038326109906847705L;
constexpr long double VelocityBound=0.00048267197598761413L;

static void compare(Point f, Point t, int32_t vl=1536000, int32_t al=5120000, int32_t home=0) {
    MotorStream::Curve curve; Oracle::Curve old; Float1401::Curve deployed;
    const bool valid=curve.Build(f,t,vl,al,home);
    CHECK(valid==old.Build({f.q,f.v,f.a},{t.q,t.v,t.a},vl,al,home));
    CHECK(valid==deployed.Build({f.q,f.v,f.a},{t.q,t.v,t.a},vl,al,home));
    if (!valid) { ++rejected; return; }
    ++accepted;
    // Direct continuous-time Hermite quintic; does not use the production
    // forward-difference tables or integer helper. Position stays q0-relative.
    const long double d=int64_t(t.q)-f.q, v0=f.v*.02L, v1=t.v*.02L;
    const long double a0=f.a*.0004L, a1=t.a*.0004L;
    const long double c[6]={0,v0,a0/2,
        10*d-6*v0-4*v1-1.5L*a0+.5L*a1,
        -15*d+8*v0+7*v1+1.5L*a0-a1,
        6*d-3*v0-3*v1-.5L*a0+.5L*a1};
    for (unsigned tick=1; tick<=400; ++tick) {
        int32_t q,v,oq,ov,dq,dv;
        curve.Tick(q,v); old.Tick(oq,ov); deployed.Tick(dq,dv);
        const long double s=tick/400.0L;
        const long double exactQ=((((c[5]*s+c[4])*s+c[3])*s+c[2])*s+c[1])*s;
        const long double exactV=((((5*c[5]*s+4*c[4])*s+3*c[3])*s+2*c[2])*s+c[1])*50;
        const long double eq=std::fabs(curve.p_[0]/Scale-exactQ);
        const long double ev=std::fabs(curve.v_[0]/Scale-exactV);
        maxQ40ErrorQ=std::max(maxQ40ErrorQ,eq); maxQ40ErrorV=std::max(maxQ40ErrorV,ev);
        const long double outputQ=std::fabs((int64_t(q)-f.q)-exactQ);
        const long double outputV=std::fabs(v-exactV);
        maxOutputErrorQ=std::max(maxOutputErrorQ,outputQ); maxOutputErrorV=std::max(maxOutputErrorV,outputV);
        CHECK(eq<=PositionBound+1.e-7L);
        CHECK(ev<=VelocityBound+1.e-7L);
        CHECK(outputQ<=.5L+PositionBound+1.e-7L);
        CHECK(outputV<=.5L+VelocityBound+1.e-7L);
        CHECK(std::abs(int64_t(q)-oq)<=1 && std::abs(int64_t(v)-ov)<=1);
        CHECK(std::abs(int64_t(q)-dq)<=1 && std::abs(int64_t(v)-dv)<=1);
        floatDifferentQ+=q!=dq; floatDifferentV+=v!=dv;
        legacyDifferentQ+=q!=oq; legacyDifferentV+=v!=ov;
        CHECK(curve.Finished()==(tick==400));
        if(tick==400) CHECK(q==t.q && v==t.v);
    }
    for(unsigned i=0;i<3;++i){int32_t q,v;curve.Tick(q,v);CHECK(q==t.q && v==t.v && curve.Finished());}
    CHECK(curve.End().q==t.q && curve.End().v==t.v && curve.End().a==t.a);
}

static void exactFixture(const char* path) {
    auto file=std::fopen(path,"rb");CHECK(file);
    uint32_t magic,count;CHECK(std::fread(&magic,4,1,file)==1 && magic==0x51463430);
    CHECK(std::fread(&count,4,1,file)==1 && count>=64);
    for(uint32_t index=0;index<count;++index){
        int32_t input[9];int64_t expectedDifferences[11];
        CHECK(std::fread(input,sizeof input,1,file)==1);
        CHECK(std::fread(expectedDifferences,sizeof expectedDifferences,1,file)==1);
        Point f{input[0],input[1],input[2]},t{input[3],input[4],input[5]};
        MotorStream::Curve curve;CHECK(curve.Build(f,t,input[6],input[7],input[8]));
        for(unsigned i=0;i<6;++i)CHECK(curve.p_[i]==expectedDifferences[i]);
        for(unsigned i=0;i<5;++i)CHECK(curve.v_[i]==expectedDifferences[i+6]);
        for(unsigned tick=1;tick<=400;++tick){
            // Values are generated by Python arbitrary-precision polynomial
            // evaluation, independently of the production difference maps.
            struct Expected {int32_t q,v;double relative,velocity;} expected;
            static_assert(sizeof(Expected)==24,"Fixture ABI");
            CHECK(std::fread(&expected,sizeof expected,1,file)==1);
            int32_t q,v;curve.Tick(q,v);
            CHECK(std::abs(int64_t(q)-expected.q)<=1 && std::abs(int64_t(v)-expected.v)<=1);
            CHECK(std::fabs((int64_t(q)-f.q)-expected.relative)<=.5+double(PositionBound)+1.e-7);
            CHECK(std::fabs(v-expected.velocity)<=.5+double(VelocityBound)+1.e-7);
            if(tick==400)CHECK(q==t.q && v==t.v);
            ++exactFixtureTicks;
        }
    }
    CHECK(std::fgetc(file)==EOF);std::fclose(file);
}

int main(int argc,char** argv){
    CHECK(argc>=2);exactFixture(argv[1]);
    const int32_t positions[]={INT32_MIN,INT32_MIN+1,-2560000,-1,0,1,2560000,INT32_MAX-1,INT32_MAX};
    const int32_t homes[]={INT32_MIN,-2560000,-1,0,1,2560000,INT32_MAX};
    for(auto q:positions)for(auto home:homes)compare({q,0,0},{q,0,0},1536000,5120000,home);
    const int32_t velocities[]={INT32_MIN,-1536001,-1536000,-512,-1,0,1,512,1536000,1536001,INT32_MAX};
    const int32_t accelerations[]={INT32_MIN,-5120001,-5120000,-1,0,1,5120000,5120001,INT32_MAX};
    for(auto v:velocities)for(auto a:accelerations){
        compare({0,v,a},{1,v,a});compare({0,0,0},{0,0,0},v,a);
    }
    for(int32_t v=-1536000;v<=1536000;v+=51200)
        for(int32_t a=-5120000;a<=5120000;a+=128000){
            // Exact constant-acceleration and near-limit quintics in both signs.
            const int32_t endingV=v+a/50;
            const int32_t distance=v/50+a/5000;
            compare({0,v,a},{distance,endingV,a});
            compare({0,v,a},{distance+1,endingV,a});
            compare({0,v,a},{distance-1,endingV,a});
        }
    for(auto q:positions)for(int32_t d:{-40001,-40000,-2000,-1,0,1,2000,40000,40001}){
        const int64_t end=int64_t(q)+d;if(end<INT32_MIN || end>INT32_MAX)continue;
        for(auto home:{-1,0,1})compare({q,0,0},{int32_t(end),0,0},1536000,5120000,home);
    }
    std::mt19937 random(20261014);
    const unsigned samples=argc>2 ? unsigned(std::strtoul(argv[2],nullptr,10)) : 100000;
    for(unsigned i=0;i<samples;++i){
        const int32_t v0=int32_t(random()%3072001)-1536000;
        const int32_t v1=v0+int32_t(random()%102401)-51200;
        const int32_t a0=int32_t(random()%10240001)-5120000;
        const int32_t a1=int32_t(random()%10240001)-5120000;
        const int32_t q=int32_t(int64_t(random()%4000000001U)-2000000000LL);
        const int32_t d=int32_t((int64_t(v0)+v1)/100)+int32_t(random()%11)-5;
        compare({q,v0,a0},{q+d,v1,a1},1536000,5120000,int32_t(random()%200000001)-100000000);
    }
    // Rejection must preserve an in-flight curve, including the remaining ticks.
    MotorStream::Curve reuse, reference;
    CHECK(reuse.Build({-10,0,0},{10,0,0},1536000,5120000));
    CHECK(reference.Build({-10,0,0},{10,0,0},1536000,5120000));
    for(unsigned tick=1;tick<=400;++tick){
        int32_t q,v,rq,rv;reuse.Tick(q,v);reference.Tick(rq,rv);CHECK(q==rq && v==rv);
        if(tick==200)CHECK(!reuse.Build({INT32_MAX,0,0},{INT32_MAX,0,0},1536000,5120000,1));
    }
    CHECK(accepted>500 && rejected>500 && sizeof(MotorStream::Curve)==112);
    std::printf("checks=%llu accepted=%llu rejected=%llu exact_fraction_ticks=%llu curve_bytes=%zu hardware=NO\n",
        (unsigned long long)checks,(unsigned long long)accepted,(unsigned long long)rejected,
        (unsigned long long)exactFixtureTicks,sizeof(MotorStream::Curve));
    std::printf("float1401_different_q=%llu v=%llu legacy1304_different_q=%llu v=%llu max_difference_allowed=1_step\n",
        (unsigned long long)floatDifferentQ,(unsigned long long)floatDifferentV,
        (unsigned long long)legacyDifferentQ,(unsigned long long)legacyDifferentV);
    std::printf("max_Q40_polynomial_error_q=%.12Lf v=%.12Lf max_integer_output_error_q=%.12Lf v=%.12Lf\n",
        maxQ40ErrorQ,maxQ40ErrorV,maxOutputErrorQ,maxOutputErrorV);
}
